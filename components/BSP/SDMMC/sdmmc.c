/**
 ****************************************************************************************************
 * @file        sdmmc.c
 * @author      sjwu
 * @version     V1.0
 * @date        2025-01-01
 * @brief       TF驱动代码
 *  
 ****************************************************************************************************
 * @attention
 *
 * 实验平台:正点原子 ESP32-P4 开发板
 * 在线视频:www.yuanzige.com
 * 技术论坛:www.openedv.com
 * 公司网址:www.alientek.com
 * 购买地址:openedv.taobao.com
 *
 ****************************************************************************************************
 */

#include "sdmmc.h"
#include "esp_ldo_regulator.h"


const char* sdmmc_tag = "sdmmc";
sdmmc_card_t *card = NULL;
const char mount_point[] = MOUNT_POINT;
static uint8_t sdmmc_mount_flag = 0x00;


/**
 * @brief       SD卡初始化并挂载SD卡
 * @param       无
 * @retval      ESP_OK:初始化成功
 */
esp_err_t sdmmc_init(void)
{
    esp_err_t ret = ESP_OK;
    
    /* 防止多次调用这个函数初始化 */
    if (sdmmc_mount_flag == 0x01 && card != NULL)
    {
        sdmmc_unmount();    /* 取消挂载 */
    }
    
    esp_vfs_fat_sdmmc_mount_config_t mount_config = {
        .format_if_mount_failed = false,        /* 挂载FAT分区 */
        .max_files              = 5,            /* 打开分文件最大数量 */
        .allocation_unit_size   = 16 * 1024     /* 分配单位大小 */
    };

    sdmmc_host_t sdmmc_host = SDMMC_HOST_DEFAULT();     /* SDMMC控制器默认设置,20MHz通信频率 */
    sdmmc_host.max_freq_khz = SDMMC_FREQ_HIGHSPEED;     /* 设置速度最大值为40MHz */

    sdmmc_slot_config_t sdmmc_config = SDMMC_SLOT_CONFIG_DEFAULT(); /* SDMMC控制器硬件相关设置,总线宽度为4位 */
    sdmmc_config.width = 4;                 /* SDMMC总线宽度为4 */
    sdmmc_config.clk   = SDMMC_PIN_CLK;     /* SDMMC的时钟引脚 */
    sdmmc_config.cmd   = SDMMC_PIN_CMD;     /* SDMMC的命令引脚 */
    sdmmc_config.d0    = SDMMC_PIN_D0;      /* SDMMC的数据0引脚 */
    sdmmc_config.d1    = SDMMC_PIN_D1;      /* SDMMC的数据1引脚 */
    sdmmc_config.d2    = SDMMC_PIN_D2;      /* SDMMC的数据2引脚 */
    sdmmc_config.d3    = SDMMC_PIN_D3;      /* SDMMC的数据3引脚 */
    sdmmc_config.flags |= SDMMC_SLOT_FLAG_INTERNAL_PULLUP;  /* 内部弱上拉 */

    ret = esp_vfs_fat_sdmmc_mount(mount_point, &sdmmc_host, &sdmmc_config, &mount_config, &card);   /* 挂载文件系统(内部会调用sdmmc_host_init_slot初始化SDMMC) */
    if (ret != ESP_OK)
    {
        if (ret == ESP_FAIL)
        {
            ESP_LOGE(sdmmc_tag, "Failed to mount filesystem. "
                     "If you want the card to be formatted, set the EXAMPLE_FORMAT_IF_MOUNT_FAILED menuconfig option.");
        }
        else
        {
            ESP_LOGE(sdmmc_tag, "Failed to initialize the card (%s). "
                     "Make sure SD card lines have pull-up resistors in place.", esp_err_to_name(ret));
        }
        sdmmc_mount_flag = 0xFF;
        return ESP_FAIL;
    }

    /* 打印当前TF卡相关信息 */
    sdmmc_card_print_info(stdout, card);
    sdmmc_mount_flag = 0x01;
    return ESP_OK;
}

/**
 * @brief       取消挂载SD卡
 * @param       无
 * @retval      ESP_OK:初始化成功
 */
esp_err_t sdmmc_unmount(void)
{
    ESP_ERROR_CHECK(esp_vfs_fat_sdcard_unmount(mount_point, card));
    sdmmc_mount_flag = 0x00;
    return ESP_OK;
}